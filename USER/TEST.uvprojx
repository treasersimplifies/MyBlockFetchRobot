# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\pwm10111314;..\HARDWARE\engines;..\HARDWARE\GPS;..\HARDWARE\HCSR04;..\HARDWARE\pwm912;..\HARDWARE\stm32f4xx_usart;..\USMART;..\HARDWARE\KEY
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f40_41xxx.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/pwm10111314/: pwm10111314.c
    ../HARDWARE/engines/: engines.c
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/pwm912/: pwm912.c
    ../HARDWARE/KEY/: key.c
  group README
    ../: readme.txt test.txt
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
